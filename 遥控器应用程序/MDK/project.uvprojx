# Keil uVision project project.uvprojx, settings and files
target baodian7302 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L151RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00014000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: General_Output +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_HD,BOOTLOADER_ENABLED,IWDG_ENABLED,GENERAL_APP,HARDWARE_TEST111,INIT_FLASH
  c include: ..\User;..\Libraries\STM32L1xx_StdPeriph_V1.1.1\inc;..\Libraries\STM32L1xx_StdPeriph_V1.1.1\src;..\Libraries\CMSIS;..\OS-uCOSII\core;..\OS-uCOSII\port;..\BSP;..\User\driver;..\User\interface;..\User\logic;..\User
  memory RVCT4: ROM 0x8008000 size 0x2c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/CMSIS/: startup_stm32l1xx_hd.s
  group Lib/Cmsic
    ../Libraries/CMSIS/: system_stm32l1xx.c system_stm32l1xx.h stm32l1xx.h
  group Lib/STM32L1xx_StdPeriph
    ../Libraries/STM32L1xx_StdPeriph_V1.1.1/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group uCOSII_core
    ../Libraries/STM32L1xx_StdPeriph_V1.1.1/src/: stm32l1xx_tim.c
    ../OS-uCOSII/core/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII_port
    ../OS-uCOSII/port/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group BSP
    ../BSP/: Bsp.c
  group User/Driver
    ../User/driver/: driver.c adc.c oled.c pwr.c led.c key.c keyled.c beep.c uart.c ir_send.c input.c rfid_driver.c rfid_cc1101.c ds2756.c eepromarm.c ncio.c uart1.c timer.c
  group User/Interface
    ../User/interface/: interface.c BeepApp.c KeyApp.c iwdg.c InterfaceMenu.c hardware_test.c temp.c ActionInfoInit.c
  group User/Logic
    ../User/logic/: Battery.c IrMng.c RfidMng.c iapupdate.c RfidUpdate.c logic.c
  group User/zzz
    ../User/driver/: zzz.c
  group User
    ../User/: main.c stm32l1xx_it.c
  group readme
    ../User/: readme.txt
software components: CMSIS:CORE 5.5.0
